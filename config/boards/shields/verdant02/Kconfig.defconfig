## config/boards/shields/zarroc_split/Kconfig.defconfig
```kconfig
if SHIELD_ZARROC_SPLIT

config ZMK_KEYBOARD_NAME
    default "Zarroc Split"

config ZMK_SPLIT
    default n

endif
```
